# Keil uVision project lab6-c51.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F104E STC
  cpu: IRAM(0-0x7F) IROM(0-0xFF8) CLOCK(35000000)
  output: lab6-c51 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c STC15F2K60S2.H
